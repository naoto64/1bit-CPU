# Repository naoto64/1bit-CPU

File README.md:

# 1bit-CPU
1bit CPU using 74HC series logic IC.

## Overview
This is a 1bit CPU KiCad file.
You can make a CPU using the 74HC series logic IC.

## Circuit Diagram

## Description
Left switch: Controls MUX to choose whether to update Reg A or PC  
Right switch: Controls second XOR operand or sets destination PC address

```
LR
00: MUX=0, RA=RA^0=RA,  PC=!PC
01: MUX=0, RA=RA^1=!RA, PC=!PC
10: MUX=1, RA=RA,       PC=0
11: MUX=1, RA=RA,       PC=1
```

In regular words:  
OFF, OFF will preserve the value of A and advance PC (0->1, 1->0)  
OFF, ON will invert the value of A (0->1, 1->0) and advance PC (0->1, 1->0)  
ON, OFF will preserve the value of A and set PC to 0  
ON, ON will preserve the value of A and set PC to 1  

```
01 23 | Function | Looped C equivalent | Description
----------------------------------------------------------------------------
00 00 | NOP, NOP | void; void;         | Do nothing
00 01 | NOP, INV | void; a=!a;         | Half frequency blink
00 10 | NOP, NOP | void; void;         | Do nothing
00 11 | NOP, HLT | void; while(1);     | Halt forever
01 00 | INV, NOP | a=!a; void;         | Half frequency blink
01 01 | INV, INV | a=!a; a=!a;         | Maximum frequency blink
01 10 | INV, NOP | a=!a; void;         | Half frequency blink
01 11 | INV, HLT | a=!a; while(1);     | Usually one state change, then halt
10 00 | HLT, NOP | while(1); void;     | Halt forever
10 01 | HLT, INV | while(1); a=!a;     | At most one state change, then halt
10 10 | HLT, NOP | while(1); void;     | Halt forever
10 11 | HLT, HLT | while(1); while(1); | Halt forever
11 00 | NOP, NOP | void; void;         | Do nothing
11 01 | NOP, INV | void; a=!a;         | Half frequency blink
11 10 | NOP, NOP | void; void;         | Do nothing
11 11 | NOP, HLT | void; while(1);     | Halt forever
```

## Video

## KiCad design 1bit-cpu/1bit-cpu.kicad_pcb

Board: 2 copper layers, 70.0 x 85.0 mm, 38 parts (0 on the bottom side), 32 nets.

Parts:
C1, C4, C5, C6, C7: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C2: 10μ; C_Disc_D4.3mm_W1.9mm_P5.00mm
C3: 10u; C_Disc_D4.3mm_W1.9mm_P5.00mm
D1, D2, D3, D4: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
F1: 100mA; Fuse_Bourns_MF-RG300
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1: USB_Type_C; USB_C_PowerOnly
LED1, LED2, LED3, LED4: LED; LED_D5.0mm
R1, R5, R9, R10: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2, R6, R7, R8: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1, SW2: SW; SW_DIP_SPSTx02_Slide_9.78x7.26mm_W7.62mm_P2.54mm
SW3: SW_Push; SW_PUSH_6mm
U1: 74HC04; DIP-14_W7.62mm_Socket
U2: 74HC74; DIP-14_W7.62mm_Socket
U3: 74HC00; DIP-14_W7.62mm_Socket
U4: 74HC153; DIP-16_W7.62mm_Socket

Connections:
+5V: C3.2, C4.2, C5.2, C6.2, C7.2, F1.2, LED4.2 (A), R1.1, R9.1, R10.1, U1.14 (VCC), U2.4 (~S), U2.10 (~S), U2.14 (VCC), U3.14 (VCC), U4.16 (VCC)
GND: C1.1, C3.1, C4.1, C5.1, C6.1, C7.1, J1.A12 (GND), LED1.1 (K), LED2.1 (K), LED3.1 (K), R2.2, SW3.2, U1.7 (GND), U2.7 (GND), U3.7 (GND), U4.1 (1G), U4.2 (B), U4.3 (1C3), U4.4 (1C2), U4.8 (GND), U4.12 (2C2), U4.13 (2C3), U4.15 (2G)
unnamed: C2.1, R3.1, R4.1
unnamed: C2.2, U1.10, U1.13
unnamed: D1.2 (A), SW1.1
unnamed: D1.1 (K), D2.1 (K), R7.2, U1.1, U2.9 (Q)
unnamed: D2.2 (A), SW1.2
unnamed: D3.2 (A), SW2.1
unnamed: D3.1 (K), D4.1 (K), U1.2
unnamed: D4.2 (A), SW2.2
unnamed: F1.1, J1.A9 (VBUS)
unnamed: LED1.2 (A), R6.1
unnamed: LED2.2 (A), R7.1
unnamed: LED3.2 (A), R8.1
unnamed: LED4.1 (K), R2.1
unnamed: R3.2, U1.9
unnamed: R4.2, U1.8, U1.11
unnamed: R5.2, R8.2, U1.12
unnamed: R9.2, SW1.4, SW2.4, U1.3
unnamed: R10.2, SW1.3, SW2.3, U1.5
unnamed: R5.1, U2.3 (C), U2.11 (C)
unnamed: U2.2 (D), U4.7 (Y1)
unnamed: R6.2, U2.5 (Q), U3.1, U3.4, U4.5 (1C1)
unnamed: C1.2, R1.2, SW3.1, U2.1 (~R), U2.13 (~R)
unnamed: U2.12 (D), U4.9 (Y2)
unnamed: U2.8 (~Q), U4.10 (2C0)
unnamed: U3.3, U3.5, U3.9
unnamed: U3.6, U3.12
unnamed: U3.8, U3.13
unnamed: U3.11, U4.6 (1C0)
unnamed: U1.6, U3.2, U3.10, U4.11 (2C1)
unnamed: U1.4, U4.14 (A)

## Commit log

2023-11-25 Create img
